Commit message: Use box instead mesh

File: turtlebot_description/urdf/turtlebot.urdf (robot description, URDF)
Before this commit: robot simple_box, 11 links, 10 joints
Links:
- link base_plate: geometry collision box size=0.5 0.5 0.02; visual box size=0.5 0.5 0.02
